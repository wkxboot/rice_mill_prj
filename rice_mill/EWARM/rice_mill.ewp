# IAR project rice_mill.ewp, settings and files
configuration rice_mill (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103T6 ST STM32F103T6
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F103xE
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM3; ../Drivers/CMSIS/Device/ST/STM32F1xx/Include; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS; ../Drivers/CMSIS/Include; ../libraries; ../libraries/log; ../libraries/fifo; ../libraries/util; ../libraries/segger_rtt; ../Middlewares/Third_Party/freemodbus_slave/modbus/functions; ../Middlewares/Third_Party/freemodbus_slave/modbus/rtu; ../Middlewares/Third_Party/freemodbus_slave/modbus/include; ../Middlewares/Third_Party/freemodbus_slave/port; ../Middlewares/Third_Party/freemodbus_master/modbus/include; ../Middlewares/Third_Party/freemodbus_master/modbus/rtu; ../Middlewares/Third_Party/freemodbus_master/port; ../Src/user
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Inc
  OBJCOPY.OOCOutputFile: rice_mill.srec
  ILINK.IlinkOutputFile: rice_mill.out
  ILINK.IlinkIcfFile: stm32f103xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f103xe.s
  group Application/User
    ../Src/: dma.c freertos.c gpio.c iwdg.c main.c stm32f1xx_hal_msp.c stm32f1xx_it.c usart.c tim.c spi.c adc.c
  group Application/User/user
    ../Src/user/: mb_slave_msg.c mb_slave_reg.c rm_bsp.c
    ../Src/: user_tasks.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_adc.c
  group libraries/fifo
    ../libraries/fifo/: app_fifo.c
  group libraries/log
    ../libraries/log/: app_log.c
  group libraries/segger_rtt
    ../libraries/segger_rtt/: RTT_Syscalls_IAR.c SEGGER_RTT.c SEGGER_RTT_printf.c
  group libraries/util
    ../libraries/util/: app_error.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM3/: port.c portasm.s
  group Middlewares/mb_master
    ../Middlewares/Third_Party/freemodbus_master/modbus/: mb_m.c
  group Middlewares/mb_master/mb_func_m
    ../Middlewares/Third_Party/freemodbus_master/modbus/functions/: mbfunccoils_m.c mbfuncdisc_m.c mbfuncholding_m.c mbfuncinput_m.c mbfuncother_m.c mbutils_m.c
  group Middlewares/mb_master/mb_port_m
    ../Middlewares/Third_Party/freemodbus_master/port/: mb_cb_m.c port_m.c portevent_m.c portserial_m.c porttimer_m.c
  group Middlewares/mb_master/mb_rtu_m
    ../Middlewares/Third_Party/freemodbus_master/modbus/rtu/: mbcrc_m.c mbrtu_m.c
  group Middlewares/mb_slave
    ../Middlewares/Third_Party/freemodbus_slave/modbus/: mb.c
  group Middlewares/mb_slave/mb_func
    ../Middlewares/Third_Party/freemodbus_slave/modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
  group Middlewares/mb_slave/mb_port
    ../Middlewares/Third_Party/freemodbus_slave/port/: portevent.c portother.c portserial.c porttimer.c
  group Middlewares/mb_slave/mb_rtu
    ../Middlewares/Third_Party/freemodbus_slave/modbus/rtu/: mbcrc.c mbrtu.c
